options:
  parameters:
    generate_options: qt_gui
    id: ofdmreciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: average_length
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: average_length_0
  id: variable
  parameters:
    value: '16'
  states: {state: disabled}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: fft_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {state: disabled}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {state: disabled}
- name: packet_len
  id: variable
  parameters:
    value: '93'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\saite\Downloads\new.png
    type: byte
  states: {state: disabled}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000000'
    max_iter: '4000'
    scale: 1/(fft_len*1000000)
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_length
    max_iter: '64'
    scale: 1/(fft_len*average_length)
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-26,-25,-24,-23,-22,-20,-19,-18,-17,-16,-15,-14,-13,-12,-11,-10,-9,-8,-6,-5,-4,-3,-2,-1,1,2,3,4,5,6,8,9,10,11,12,13,14,15,16,17,18,19,20,22,23,24,25,26),)
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: ((1,1,1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,vectorSize=16):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Maximum Hold',   # will show up in GRC
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[np.float32]
              )
              self.maximum=0;
              self.maximum1=0;
              self.papr=0;
              self.papr1=0;

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.maximum1 = np.max(input_items[0])
              if(self.maximum<self.maximum1):
                  self.maximum = self.maximum1
              self.papr=self.maximum1/np.average(input_items[0])
              if(self.papr1<self.papr):
                  self.papr1=self.papr
              output_items[0][:] = self.papr1
              return len(output_items[0])
    vectorSize: fft_len
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0,buffers=128,buflen=32768
    bb_gain0: '200'
    bw0: 1e6
    freq0: 7e8
    gain0: '100'
    gain_mode0: 'False'
    if_gain0: '200'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"rxspectrumafteros"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"RX_Spectrum"'
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: maxsignal
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: papr
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: average power recieved
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: average power recieved
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: average power recieved
    type: float
  states: {}
- name: qtgui_number_sink_0_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: papr
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    name: Scope Plot 2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx_signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: recieve_signal
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: max_signal
  states: {state: disabled}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: max_signal
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: mov_avg_signal
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: mov_avg_signal
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mov_avg_signal
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: mov_avg_signal
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {state: disabled}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {state: disabled}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {state: disabled}
- name: virtual_source_2_1_1
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: max_signal
  states: {state: disabled}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: max_signal
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_max_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_real_0, '0', blocks_max_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_0_0, '0', qtgui_number_sink_0_0_1, '0']
- [blocks_max_xx_0, '0', virtual_sink_0_0_0, '0']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_, '0']
- [blocks_max_xx_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', virtual_sink_2, '0']
- [blocks_moving_average_xx_0_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', virtual_sink_2_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_file_sink_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_0_0, '0', blocks_uchar_to_float_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_0_0_1, '0']
- [osmosdr_source_0, '0', blocks_complex_to_real_0_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0_0_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [virtual_source_1, '0', blocks_divide_xx_0, '1']
- [virtual_source_1_0, '0', blocks_divide_xx_0_0, '1']
- [virtual_source_2_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_2_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_2_1_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_2_1_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_5, '0', blocks_divide_xx_0, '0']
- [virtual_source_5_0, '0', blocks_divide_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
