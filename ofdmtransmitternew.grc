options:
  parameters:
    generate_options: qt_gui
    id: ofdmtransmitter
    output_language: python
    title: ofdmtransmitter
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: p_length
  id: variable_qtgui_range
  parameters:
    label: packet length
    start: '20'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 30e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\bmgna\Downloads\new.png
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\bmgna\Downloads\new1.png
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: OFDM_trans.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\bmgna\Downloads\solo.png
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: OFDM_trans.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.005'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,50)
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-26,-25,-24,-23,-22,-20,-19,-18,-17,-16,-15,-14,-13,-12,-11,-10,-9,-8,-6,-5,-4,-3,-2,-1,1,2,3,4,5,6,8,9,10,11,12,13,14,15,16,17,18,19,20,22,23,24,25,26),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: ((1,1,1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-26,-25,-24,-23,-22,-20,-19,-18,-17,-16,-15,-14,-13,-12,-11,-10,-9,-8,-6,-5,-4,-3,-2,-1,1,2,3,4,5,6,8,9,10,11,12,13,14,15,16,17,18,19,20,22,23,24,25,26),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: ((1,-1,1,-1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: 16//4
    fft_len: '16'
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((1,-1,1,-1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,vectorSize=16):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Maximum Hold',   # will show up in GRC
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[np.float32]
              )
              self.maximum=0;
              self.maximum1=0;
              self.papr=0;
              self.papr1=0;

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.maximum1 = np.max(input_items[0])
              if(self.maximum<self.maximum1):
                  self.maximum = self.maximum1
              self.papr=self.maximum1/np.average(input_items[0])
              if(self.papr1<self.papr):
                  self.papr1=self.papr
              output_items[0][:] = self.papr1
              return len(output_items[0])
    vectorSize: fft_len
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0,buffers=128,buflen=32768
    bb_gain0: '200'
    bw0: 1e6
    freq0: 7e8
    gain0: '100'
    if_gain0: '200'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"TX_Spectrum"'
    type: complex
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"RX_Spectrum"'
    type: float
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"input_Spectrum"'
    type: float
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"TX_Spectrum after ss"'
    type: complex
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: PAPR
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_1_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: BER
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: Scope Plot1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    name: Scope Plot 2
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx_signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Rx_signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input_signal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: recieve_signal
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: receive_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: receive_signal
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: input_signal
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_source_2_1_1
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1_2, '0']
- [analog_sig_source_x_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_1, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_file_source_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_1, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_float_to_char_0, '0', fec_ber_bf_0, '0']
- [blocks_float_to_char_0_0, '0', fec_ber_bf_0, '1']
- [blocks_multiply_const_vxx_1, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle_1, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_1, '0', digital_ofdm_tx_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_1, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_file_sink_3, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_uchar_to_float_0_1, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_0_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_ofdm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_0, '0', qtgui_number_sink_0_0_0_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0_0_0_1_0, '0']
- [virtual_source_0, '0', blocks_float_to_char_0_0, '0']
- [virtual_source_1, '0', blocks_float_to_char_0, '0']
- [virtual_source_2, '0', digital_ofdm_rx_0, '0']
- [virtual_source_2, '0', digital_ofdm_rx_0_0_0, '0']
- [virtual_source_2_1_1, '0', blocks_complex_to_mag_squared_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
